Commit message: working on refine grasp

File: object_urdfs/003_cracker_box.urdf (robot description, URDF)
Before this commit: robot 003_cracker_box, 1 links, 0 joints
Links:
- link 003_cracker_box_link: mass None -> 0.0
